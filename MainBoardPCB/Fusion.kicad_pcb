# Repository jeandet/Fusion

## KiCad design MainBoardPCB/Fusion.kicad_pcb

Parts:
C101, C102, C103, C104: 10µF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
J101: Conn_02x08_Odd_Even; PinSocket_2x08_P2.54mm_Vertical
J102: Conn_02x16_Odd_Even; PinSocket_2x16_P2.54mm_Vertical
J103: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
JP101, JP102, JP103: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R101: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder

Connections:
/ADC_IN0: J101.1
/ADC_IN1: J101.2
/ADC_IN2: J101.3
/ADC_IN3: J101.4
/ADC_IN4: J101.5
/ADC_IN5: J101.6
/Alert: R101.2; also elsewhere on the board
/DAC_OUT1: J101.9
/DAC_OUT2: J101.10
/EXT_SPI_MISO: J102.3; also elsewhere on the board
/EXT_SPI_MOSI: J102.7; also elsewhere on the board
/EXT_SPI_NSS: J102.9; also elsewhere on the board
/EXT_SPI_SCK: J102.5; also elsewhere on the board
/FPGA/3.3V: C101.1, C102.1, J101.13, J101.14, J102.1, J103.5, J103.6, JP101.1 (A), JP102.1 (A), JP103.1 (A), R101.1; also elsewhere on the board
/FPGA/5V: C103.1, C104.1, J101.15, J101.16, J103.3, J103.4; also elsewhere on the board
/FPGA_BANK0_IO0: J103.19; also elsewhere on the board
/FPGA_BANK0_IO1: J103.20; also elsewhere on the board
/FPGA_BANK0_IO2: J103.17; also elsewhere on the board
/FPGA_BANK0_IO3: J103.18; also elsewhere on the board
/FPGA_BANK0_IO4: J103.15; also elsewhere on the board
/FPGA_BANK0_IO5: J103.16; also elsewhere on the board
/FPGA_BANK0_IO6: J103.13; also elsewhere on the board
/FPGA_BANK0_IO7: J103.14; also elsewhere on the board
/FPGA_BANK0_IO8: J103.11; also elsewhere on the board
/FPGA_BANK0_IO9: J103.12; also elsewhere on the board
/FPGA_BANK0_VCCIO: J103.9, J103.10, JP101.2 (B); also elsewhere on the board
/FPGA_BANK1_IO0: J103.35; also elsewhere on the board
/FPGA_BANK1_IO1: J103.36; also elsewhere on the board
/FPGA_BANK1_IO2: J103.33; also elsewhere on the board
/FPGA_BANK1_IO3: J103.34; also elsewhere on the board
/FPGA_BANK1_IO4: J103.31; also elsewhere on the board
/FPGA_BANK1_IO5: J103.32; also elsewhere on the board
/FPGA_BANK1_IO6: J103.29; also elsewhere on the board
/FPGA_BANK1_IO7: J103.30; also elsewhere on the board
/FPGA_BANK1_IO8: J103.27; also elsewhere on the board
/FPGA_BANK1_IO9: J103.28; also elsewhere on the board
/FPGA_BANK1_IO10: J103.25; also elsewhere on the board
/FPGA_BANK1_IO11: J103.26; also elsewhere on the board
/FPGA_BANK1_IO12: J103.23; also elsewhere on the board
/FPGA_BANK1_IO13: J103.24; also elsewhere on the board
/FPGA_BANK1_IO14: J103.21; also elsewhere on the board
/FPGA_BANK1_IO15: J103.22; also elsewhere on the board
/FPGA_BANK1_VCCIO: J103.37, J103.38, JP102.2 (B); also elsewhere on the board
/FPGA_BANK6_IO0: J102.15; also elsewhere on the board
/FPGA_BANK6_IO1: J102.16; also elsewhere on the board
/FPGA_BANK6_IO2: J102.13; also elsewhere on the board
/FPGA_BANK6_IO3: J102.14; also elsewhere on the board
/FPGA_BANK6_IO4: J102.11; also elsewhere on the board
/FPGA_BANK6_IO5: J102.12; also elsewhere on the board
/FPGA_BANK7_IO0: J102.29; also elsewhere on the board
/FPGA_BANK7_IO1: J102.30; also elsewhere on the board
/FPGA_BANK7_IO2: J102.27; also elsewhere on the board
/FPGA_BANK7_IO3: J102.28; also elsewhere on the board
/FPGA_BANK7_IO4: J102.25; also elsewhere on the board
/FPGA_BANK7_IO5: J102.26; also elsewhere on the board
/FPGA_BANK7_IO6: J102.23; also elsewhere on the board
/FPGA_BANK7_IO7: J102.24; also elsewhere on the board
/FPGA_BANK7_IO8: J102.21; also elsewhere on the board
/FPGA_BANK7_IO9: J102.22; also elsewhere on the board
/FPGA_BANK7_IO10: J102.19; also elsewhere on the board
/FPGA_BANK7_IO11: J102.20; also elsewhere on the board
/FPGA_BANK7_VCCIO: J102.31, JP103.2 (B); also elsewhere on the board
/I2C1_SCL: J102.6; also elsewhere on the board
/I2C1_SDA: J102.4; also elsewhere on the board
/UC_GPIO0: J102.10; also elsewhere on the board
/UC_GPIO1: J102.8; also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.2, J101.7, J101.8, J101.11, J101.12, J102.2, J102.17, J102.18, J102.32, J103.1, J103.2, J103.7, J103.8, J103.39, J103.40; also elsewhere on the board

Notes on the sheet:
SDRAM
Board to board connectors
FPGA VCCIO cfg
PSU Monitoring
FPGA
JTAG & HK
Power supply
Analog pins are not connected on this board
USB

Parts:
C401, C404: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C402: 100nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C403: 10µF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
R401: 100k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U401: NCP718xSN250; SOT-23-5

Connections:
/FPGA/3.3V: C401.1, R401.1, U401.1 (IN), U401.3 (EN); also elsewhere on the board
/FPGA/5V: C402.1, C403.1; also elsewhere on the board
/Power/PowerMonitor2/Vin: C404.1, U401.5 (OUT); also elsewhere on the board
/Power/TLV62568/PG: R401.2; also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, U401.2 (GND); also elsewhere on the board

Parts:
U1101: MT48LC16M16A2P; TSOP-II-54_22.2x10.16mm_P0.8mm

Connections:
/FPGA/3.3V: U1101.1 (VDD), U1101.3 (VDDQ), U1101.9 (VDDQ), U1101.14 (VDD), U1101.27 (VDD), U1101.43 (VDDQ), U1101.49 (VDDQ); also elsewhere on the board
/FPGA/SDRAM.A0: U1101.23 (A0); also elsewhere on the board
/FPGA/SDRAM.A1: U1101.24 (A1); also elsewhere on the board
/FPGA/SDRAM.A2: U1101.25 (A2); also elsewhere on the board
/FPGA/SDRAM.A3: U1101.26 (A3); also elsewhere on the board
/FPGA/SDRAM.A4: U1101.29 (A4); also elsewhere on the board
/FPGA/SDRAM.A5: U1101.30 (A5); also elsewhere on the board
/FPGA/SDRAM.A6: U1101.31 (A6); also elsewhere on the board
/FPGA/SDRAM.A7: U1101.32 (A7); also elsewhere on the board
/FPGA/SDRAM.A8: U1101.33 (A8); also elsewhere on the board
/FPGA/SDRAM.A9: U1101.34 (A9); also elsewhere on the board
/FPGA/SDRAM.A10: U1101.22 (A10); also elsewhere on the board
/FPGA/SDRAM.A11: U1101.35 (A11); also elsewhere on the board
/FPGA/SDRAM.A12: U1101.36 (A12); also elsewhere on the board
/FPGA/SDRAM.BA0: U1101.20 (BA0); also elsewhere on the board
/FPGA/SDRAM.BA1: U1101.21 (BA1); also elsewhere on the board
/FPGA/SDRAM.CKE: U1101.37 (CKE); also elsewhere on the board
/FPGA/SDRAM.CLK: U1101.38 (CLK); also elsewhere on the board
/FPGA/SDRAM.DQ0: U1101.2 (DQ0); also elsewhere on the board
/FPGA/SDRAM.DQ1: U1101.4 (DQ1); also elsewhere on the board
/FPGA/SDRAM.DQ2: U1101.5 (DQ2); also elsewhere on the board
/FPGA/SDRAM.DQ3: U1101.7 (DQ3); also elsewhere on the board
/FPGA/SDRAM.DQ4: U1101.8 (DQ4); also elsewhere on the board
/FPGA/SDRAM.DQ5: U1101.10 (DQ5); also elsewhere on the board
/FPGA/SDRAM.DQ6: U1101.11 (DQ6); also elsewhere on the board
/FPGA/SDRAM.DQ7: U1101.13 (DQ7); also elsewhere on the board
/FPGA/SDRAM.DQ8: U1101.42 (DQ8); also elsewhere on the board
/FPGA/SDRAM.DQ9: U1101.44 (DQ9); also elsewhere on the board
/FPGA/SDRAM.DQ10: U1101.45 (DQ10); also elsewhere on the board
/FPGA/SDRAM.DQ11: U1101.47 (DQ11); also elsewhere on the board
/FPGA/SDRAM.DQ12: U1101.48 (DQ12); also elsewhere on the board
/FPGA/SDRAM.DQ13: U1101.50 (DQ13); also elsewhere on the board
/FPGA/SDRAM.DQ14: U1101.51 (DQ14); also elsewhere on the board
/FPGA/SDRAM.DQ15: U1101.53 (DQ15); also elsewhere on the board
/FPGA/SDRAM.DQMH: U1101.39 (DQMH); also elsewhere on the board
/FPGA/SDRAM.DQML: U1101.15 (DQML); also elsewhere on the board
/FPGA/SDRAM.~CAS: U1101.17 (~CAS); also elsewhere on the board
/FPGA/SDRAM.~CS: U1101.19 (~CS); also elsewhere on the board
/FPGA/SDRAM.~RAS: U1101.18 (~RAS); also elsewhere on the board
/FPGA/SDRAM.~WE: U1101.16 (~WE); also elsewhere on the board
GND: U1101.6 (VSSQ), U1101.12 (VSSQ), U1101.28 (VSS), U1101.41 (VSS), U1101.46 (VSSQ), U1101.52 (VSSQ), U1101.54 (VSS); also elsewhere on the board

Parts:
C1201, C1202, C1206, C1207, C1209, C1210, C1211, C1212: 100nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C1203, C1208: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C1204, C1205: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1201, D1202, D1203: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1201: DX07S016JA1R1500; JAE_DX07S016JA1R1500; PARTREV 1
R1201, R1202: 5.1k; R_0402_1005Metric
R1203, R1209, R1210: 2.2k; R_0402_1005Metric
R1204, R1205: 27; R_0402_1005Metric
R1206, R1207: 1k; R_0402_1005Metric
R1208: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R1211, R1212: 4.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
SW201, SW1201: SW_Push; SW_SPST_TL3342
U1201: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U1203: W25Q16JVSS; SOIC-8_5.3x5.3mm_P1.27mm
Y201: 12MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm_HandSoldering

Connections:
/FPGA/3.3V: C1202.1, C1206.1, C1207.1, C1208.1, C1209.1, C1210.1, C1211.1, C1212.1, R1203.1, R1207.1, R1208.1, R1209.1, R1210.1, R1211.1, R1212.1, U1201.1 (IOVDD), U1201.10 (IOVDD), U1201.22 (IOVDD), U1201.33 (IOVDD), U1201.42 (IOVDD), U1201.43 (ADC_AVDD), U1201.44 (VREG_IN), U1201.48 (USB_VDD), U1201.49 (IOVDD), U1203.8 (VCC); also elsewhere on the board
/FPGA/JTAG.RST: U1201.31 (GPIO20)
/FPGA/JTAG.TCK: U1201.29 (GPIO18); also elsewhere on the board
/FPGA/JTAG.TDI: U1201.27 (GPIO16); also elsewhere on the board
/FPGA/JTAG.TDO: U1201.28 (GPIO17); also elsewhere on the board
/FPGA/JTAG.TMS: U1201.30 (GPIO19); also elsewhere on the board
/FPGA/JTAG.TRST: U1201.32 (GPIO21)
/FPGA/UART1.RX: U1201.7 (GPIO5); also elsewhere on the board
/FPGA/UART1.TX: U1201.6 (GPIO4); also elsewhere on the board
/FPGA/UART2.RX: U1201.15 (GPIO12); also elsewhere on the board
/FPGA/UART2.TX: U1201.16 (GPIO13); also elsewhere on the board
/JTAG/CLK: U1201.52 (QSPI_SCLK), U1203.6 (CLK)
/JTAG/D+: J1201.6 (D+), J1201.7 (D+), R1204.2
/JTAG/D-: J1201.5 (D-), J1201.8 (D-), R1205.2
/JTAG/DONE: U1201.12 (GPIO9)
/JTAG/ERROR_LED: D1203.1 (K), U1201.35 (GPIO23)
/JTAG/PSU.SCL: R1212.2, U1201.5 (GPIO3); also elsewhere on the board
/JTAG/PSU.SDA: R1211.2, U1201.4 (GPIO2); also elsewhere on the board
/JTAG/RX_LED: D1202.1 (K), U1201.36 (GPIO24)
/JTAG/SD0: U1201.53 (QSPI_SD0), U1203.5 (DI/IO_{0})
/JTAG/SD1: U1201.55 (QSPI_SD1), U1203.2 (DO/IO_{1})
/JTAG/SD2: U1201.54 (QSPI_SD2), U1203.3 (~WP/IO_{2})
/JTAG/SD3: U1201.51 (QSPI_SD3), U1203.7 (~HOLD/~RESET/IO_{3})
/JTAG/TX_LED: D1201.1 (K), U1201.37 (GPIO25)
/JTAG/USB_D+: R1204.1, U1201.46 (USB_DM)
/JTAG/USB_D-: R1205.1, U1201.47 (USB_DP)
/JTAG/VBUS: C1201.1, J1201.2 (VBUS), J1201.11 (VBUS)
/JTAG/reg_1.1V: C1203.1, C1204.1, C1205.1, U1201.23 (DVDD), U1201.45 (VREG_VOUT), U1201.50 (DVDD)
/JTAG/~CS: R1206.1, R1207.2, U1201.56 (QSPI_SS), U1203.1 (~CS)
/JTAG/~INIT: U1201.13 (GPIO10)
/JTAG/~PROGRAM: U1201.14 (GPIO11)
GND: C1201.2, C1202.2, C1203.2, C1204.2, C1205.2, C1206.2, C1207.2, C1208.2, C1209.2, C1210.2, C1211.2, C1212.2, J1201.1 (GND), J1201.12 (GND), J1201.S1 (SHIELD), J1201.S2 (SHIELD), J1201.S3 (SHIELD), J1201.S4 (SHIELD), J1201.S5 (SHIELD), J1201.S6 (SHIELD), R1201.1, R1202.1, SW201.2, SW1201.2, U1201.57 (GND), U1203.4 (GND), Y201.2; also elsewhere on the board
unnamed: D1201.2 (A), R1203.2
unnamed: D1202.2 (A), R1209.2
unnamed: D1203.2 (A), R1210.2
unnamed: J1201.3 (CC1), R1201.2
unnamed: J1201.9 (CC2), R1202.2
unnamed: R1206.2, SW201.1
unnamed: R1208.2, SW1201.1, U1201.26 (RUN)
unnamed: U1201.20 (XIN), Y201.1
unnamed: U1201.21 (XOUT), Y201.3

Notes on the sheet:
USB-C

Parts:
C215, C1003, C1004, C1005, C1006, C1007, C1008, C1009: 100nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
J203: DX07S016JA1R1500; JAE_DX07S016JA1R1500; PARTREV 1
R211, R212: 5.1k; R_0402_1005Metric
R213: 820; R_0402_1005Metric
R1004: 12k; R_0402_1005Metric
U202: USB6B1; SOIC-8_3.9x4.9mm_P1.27mm
U1002: USB3300-EZK; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
Y1001: Crystal_GND24_Small; Crystal_SMD_EuroQuartz_X22-4Pin_2.5x2.0mm_HandSoldering

Connections:
/FPGA/3.3V: C1006.1, C1007.1, C1008.1, C1009.1, U1002.6 (VDD3.3), U1002.16 (VDD3.3), U1002.25 (VDD3.3), U1002.30 (VDD3.3), U1002.31 (REG_EN); also elsewhere on the board
/FPGA/ULPI.CLKOUT: U1002.14 (CLKOUT); also elsewhere on the board
/FPGA/ULPI.D0: U1002.24 (DATA0); also elsewhere on the board
/FPGA/ULPI.D1: U1002.23 (DATA1); also elsewhere on the board
/FPGA/ULPI.D2: U1002.22 (DATA2); also elsewhere on the board
/FPGA/ULPI.D3: U1002.21 (DATA3); also elsewhere on the board
/FPGA/ULPI.D4: U1002.20 (DATA4); also elsewhere on the board
/FPGA/ULPI.D5: U1002.19 (DATA5); also elsewhere on the board
/FPGA/ULPI.D6: U1002.18 (DATA6); also elsewhere on the board
/FPGA/ULPI.D7: U1002.17 (DATA7); also elsewhere on the board
/FPGA/ULPI.DIR: U1002.12 (DIR); also elsewhere on the board
/FPGA/ULPI.NXT: U1002.11 (NXT); also elsewhere on the board
/FPGA/ULPI.RESET: U1002.9 (RESET); also elsewhere on the board
/FPGA/ULPI.STP: U1002.13 (STP); also elsewhere on the board
/USB/USB_D+: J203.6 (D+), J203.7 (D+), U202.3 (I/O2), U202.6 (I/O2), U1002.7 (DP)
/USB/USB_D-: J203.5 (D-), J203.8 (D-), U202.2 (I/O1), U202.7 (I/O1), U1002.8 (DM)
/USB/VBUS_SENSE: R213.1, U1002.4 (VBUS)
/USB_5V: C215.1, J203.2 (VBUS), J203.11 (VBUS), R213.2, U202.1 (VBUS), U202.8 (VBUS); also elsewhere on the board
GND: C215.2, C1003.2, C1004.2, C1005.2, C1006.2, C1007.2, C1008.2, C1009.2, J203.1 (GND), J203.12 (GND), J203.S1 (SHIELD), J203.S2 (SHIELD), J203.S3 (SHIELD), J203.S4 (SHIELD), J203.S5 (SHIELD), J203.S6 (SHIELD), R211.1, R212.1, R1004.2, U202.4 (GND), U202.5 (GND), U1002.1 (GND), U1002.2 (GND), U1002.33 (GND); also elsewhere on the board
unnamed: C1004.1, C1005.1, U1002.15 (VDD1.8), U1002.26 (VDD1.8)
unnamed: J203.3 (CC1), R211.2
unnamed: J203.9 (CC2), R212.2
unnamed: R1004.1, U1002.32 (RBIAS)
unnamed: C1003.1, U1002.29 (VDDA1.8)
unnamed: U1002.28 (XI), Y1001.1
unnamed: U1002.27 (XO), Y1001.3

Notes on the sheet:
USB-C
